# IAR project ADC_Interrupt.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MM32F0010A1T MindMotion MM32F0010A1T
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: MM32F0010A1T; USE_IAR; _DLIB_FILE_DESCRIPTOR; __ALIGNED
  ICCARM.CCDiagSuppress: Pa082,Pa089
  ICCARM.CCIncludePath2: ..\..\..\..\..\Device\CMSIS\IAR_Core; ..\..\..\..\..\Device\MM32F0010\HAL_Lib\Inc; ..\..\..\..\..\Device\MM32F0010\Include; ..\HARDWARE\ADC; ..\HARDWARE\LED; ..\SYSTEM\DELAY; ..\SYSTEM\SYS; ..\SYSTEM\UART; ..\USER
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: ADC_Awdg.out
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group STARTUP
    ../../../../../Device/MM32F0010/Source/IAR_StartAsm/: startup_mm32f0010_iar.s
    ../../../../../Device/MM32F0010/Source/: system_mm32f0010.c
  group HARDWARE
    ../HARDWARE/ADC/: adcx.c
    ../HARDWARE/LED/: led.c
  group SYSTEM
    ../SYSTEM/DELAY/: delay.c
    ../SYSTEM/SYS/: sys.c
    ../SYSTEM/UART/: uart.c
  group USER
    ../USER/: main.c
  group HALlib
    ../../../../../Device/MM32F0010/HAL_Lib/Src/: hal_adc.c hal_crc.c hal_dbg.c hal_exti.c hal_flash.c hal_gpio.c hal_i2c.c hal_iwdg.c hal_misc.c hal_pwr.c hal_rcc.c hal_spi.c hal_tim.c hal_uart.c hal_uid.c hal_ver.c hal_wwdg.c
