# Keil uVision project ADC_Interrupt.uvprojx, settings and files
target MM32Series (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: MM32F0010A1T MindMotion
  pack: MindMotion.MM32F0010_DFP.1.0.8
  cpu: IRAM(0x20000000,0x00000800) IROM(0x08000000,0x00004000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: hexfile4 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\..\..\..\..\Device\MM32F0010\Include;..\..\..\..\..\Device\MM32F0010\HAL_Lib\Inc;..\..\..\..\..\Device\CMSIS\KEIL_Core;..\USER;..\SYSTEM\UART;..\SYSTEM\SYS;..\SYSTEM\DELAY;..\HARDWARE\LED;..\HARDWARE\ADC
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x800
  group STARTUP
    ../../../../../Device/MM32F0010/Source/: system_mm32f0010.c
    ../../../../../Device/MM32F0010/Source/KEIL_StartAsm/: startup_mm32f0010_keil.s
  group HARDWARE
    ../HARDWARE/ADC/: adcx.c
    ../HARDWARE/LED/: led.c
  group SYSTEM
    ../SYSTEM/DELAY/: delay.c
    ../SYSTEM/SYS/: sys.c
    ../SYSTEM/UART/: uart.c
  group USER
    ../USER/: main.c
  group HAL_Lib
    ../../../../../Device/MM32F0010/HAL_Lib/Src/: hal_adc.c hal_crc.c hal_dbg.c hal_exti.c hal_flash.c hal_gpio.c hal_i2c.c hal_iwdg.c hal_misc.c hal_pwr.c hal_rcc.c hal_spi.c hal_tim.c hal_uart.c hal_uid.c hal_ver.c hal_wwdg.c
